v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
B 4 -50 -40 80 60 {}
B 4 70 -80 150 -20 {}
B 4 -110 -90 -20 -20 {}

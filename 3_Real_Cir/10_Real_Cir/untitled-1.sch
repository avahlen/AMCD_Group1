v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {ota-5t.sym} -40 -50 0 0 {name=x1}
